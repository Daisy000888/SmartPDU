# IAR project HTTP-PDU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: source\hardware\W25QXX; source\Libraries\STM32F10x_StdPeriph_Driver\inc; source\user\inc; source\hardware\SPI; source\hardware\USART; source\hardware\TIMER
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HTTP-PDU_bootloader.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\VMware_Zachary_Chou\trunk\ZGLJ-PDU-BootLoader\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group cmsis
    source/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group hardware/spi
    source/hardware/SPI/: spi.c
  group hardware/timer
    source/hardware/TIMER/: timer.c
  group hardware/usart
    source/hardware/USART/: usart.c
  group hardware/w25qxx
    source/hardware/W25QXX/: w25qxx.c
  group StdPeriph_Driver
    source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    source/user/src/: main.c startup_stm32f10x_hd.s stm32f10x_it.c system_stm32f10x.c systicksdelay.c timeevent.c

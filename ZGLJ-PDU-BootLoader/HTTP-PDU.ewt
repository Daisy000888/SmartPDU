<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>cmsis</name>
    <file>
      <name>$PROJ_DIR$\source\Libraries\CMSIS\CM3\CoreSupport\core_cm3.c</name>
    </file>
  </group>
  <group>
    <name>hardware</name>
    <group>
      <name>spi</name>
      <file>
        <name>$PROJ_DIR$\source\hardware\SPI\spi.c</name>
      </file>
    </group>
    <group>
      <name>timer</name>
      <file>
        <name>$PROJ_DIR$\source\hardware\TIMER\timer.c</name>
      </file>
    </group>
    <group>
      <name>usart</name>
      <file>
        <name>$PROJ_DIR$\source\hardware\USART\usart.c</name>
      </file>
    </group>
    <group>
      <name>w25qxx</name>
      <file>
        <name>$PROJ_DIR$\source\hardware\W25QXX\w25qxx.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\source\user\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\src\startup_stm32f10x_hd.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\src\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\src\system_stm32f10x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\src\systicksdelay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\src\timeevent.c</name>
    </file>
  </group>
</project>



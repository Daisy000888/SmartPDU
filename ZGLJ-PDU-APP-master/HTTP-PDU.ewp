# IAR project HTTP-PDU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: source\Libraries\STM32F10x_StdPeriph_Driver\inc; source\w5500; source\oled; source\user; source\att7053; source\httpd; source\socket; source\key; source\w25qxx
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HTTP-PDU.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\ZGLJ-PDU\trunk\ZGLJ-PDU-APP-master\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group att7053
    source/att7053/: att7053au.c
  group cmsis
    source/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group httpd
    source/httpd/: fs.c httpd.c httputil.c sockutil.c util.c
  group key
    source/key/: key.c
  group oled
    source/oled/: displayprocess.c oled.c
  group socket
    source/socket/: websocket.c
  group StdPeriph_Driver
    source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    source/user/: base64.c calender.c device.c main.c mcu_init.c process.c RS485Cascade.c RS485module.c sha1.c startup_stm32f10x_hd.s stm32f10x_it.c system_stm32f10x.c systicksdelay.c usart_debug.c
  group w25qxx
    source/w25qxx/: w25qxx.c
  group w5500
    source/w5500/: md5.c socket.c SPI3.c w5500.c

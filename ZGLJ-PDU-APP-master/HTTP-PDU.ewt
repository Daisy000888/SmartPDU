<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>att7053</name>
    <file>
      <name>$PROJ_DIR$\source\att7053\att7053au.c</name>
    </file>
  </group>
  <group>
    <name>cmsis</name>
    <file>
      <name>$PROJ_DIR$\source\Libraries\CMSIS\CM3\CoreSupport\core_cm3.c</name>
    </file>
  </group>
  <group>
    <name>httpd</name>
    <file>
      <name>$PROJ_DIR$\source\httpd\fs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\httpd\httpd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\httpd\httputil.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\httpd\sockutil.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\httpd\util.c</name>
    </file>
  </group>
  <group>
    <name>key</name>
    <file>
      <name>$PROJ_DIR$\source\key\key.c</name>
    </file>
  </group>
  <group>
    <name>oled</name>
    <file>
      <name>$PROJ_DIR$\source\oled\displayprocess.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\oled\oled.c</name>
    </file>
  </group>
  <group>
    <name>socket</name>
    <file>
      <name>$PROJ_DIR$\source\socket\websocket.c</name>
    </file>
  </group>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\source\user\base64.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\calender.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\device.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\mcu_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\process.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\RS485Cascade.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\RS485module.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\sha1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\startup_stm32f10x_hd.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\system_stm32f10x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\systicksdelay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\user\usart_debug.c</name>
    </file>
  </group>
  <group>
    <name>w25qxx</name>
    <file>
      <name>$PROJ_DIR$\source\w25qxx\w25qxx.c</name>
    </file>
  </group>
  <group>
    <name>w5500</name>
    <file>
      <name>$PROJ_DIR$\source\w5500\md5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\w5500\socket.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\w5500\SPI3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\w5500\w5500.c</name>
    </file>
  </group>
</project>


